# Keil uVision project OSEKNM.uvprojx, settings and files
target OSEKNM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OSEKNM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\Driver\stm32f407\CORE;..\..\Driver\stm32f407\FWLIB\inc;..\..\Driver\stm32f407\SYSTEM;..\..\Driver\stm32f407\USER;..\..\OsekNM_core;..\..\Driver;..\..\Driver\stm32f407\Timer;..\..\Driver\stm32f407\CAN
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group OsekNMCore
    ../../OsekNM_core/: OsekNM.c OsekNMServer.c
  group Driver
    ../../Driver/stm32f407/CORE/: startup_stm32f40_41xxx.s
    ../../Driver/stm32f407/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../Driver/stm32f407/SYSTEM/: delay.c sys.c usart.c
    ../../Driver/stm32f407/USER/: stm32f4xx_it.c system_stm32f4xx.c
    ../../Driver/stm32f407/Timer/: Timer.c
    ../../Driver/stm32f407/CAN/: CAN.c
    ../../Driver/: Driver_Common.c
  group Test
    ../: Test.c
